# IAR project u309m_arm_supply.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __LM3SxBxx__
  ICCARM.CCDiagSuppress: Pa039, Pe261, Pe340, Pa091, Pa089
  ICCARM.CCIncludePath2: ..\mxsrclib\arch\arm\; ..\mxsrclib\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: u309m_arm_supply.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: u309m_arm_supply.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 5.srec
  group lib/arch
    ../mxsrclib/arch/arm/: armadc.cpp armadc.h armcfg.cpp armcfg.h armeth.cpp armeth.h armflash.cpp armflash.h armgpio.h armiomacros.h armioregs.h armregs_cortex_m3.h armregs_lm3s.h armregs_stm32.h armregs_stm32f2xx.h armspi.cpp armspi.h counter.cpp counter.h irsarchint.cpp irsarchint.h irsarmutil.h irsdefsarch.h irsstm32f2xx_usb_hid_hardflow.cpp irsstm32f2xx_usb_hid_hardflow.h mxifal.h mxnetda.h stm32f2x7_eth_conf.h stm32f2xx_conf.h stm32f4x7_eth_conf.h stm32f4xx_conf.h
  group lib/general
    ../mxsrclib/: correct_alg.cpp correct_alg.h csvwork.cpp csvwork.h dbgprn.cpp dbgprn.h hardflowg.cpp hardflowg.h irs_chart_data.cpp irs_chart_data.h irs_codecvt.h irsadc.cpp irsadc.h irsadcabs.h irsalg.cpp irsalg.h irscalc.cpp irscalc.h irschartwin.h irsconfig.h irsconfig0.h irsconsole.h irsconsolestd.h irscpp.h irscpu.cpp irscpu.h irsdacabs.h irsdbgutil.cpp irsdbgutil.h irsdcp.cpp irsdcp.h irsdefs.h irsdefsbase.h irsdev.cpp irsdev.h irsdevices.cpp irsdevices.h irsdsp.cpp irsdsp.h irserror.cpp irserror.h irsexcept.cpp irsexcept.h irsfilter.cpp irsfilter.h irsfinal.h irsfunnel.cpp irsfunnel.h irsgpio.cpp irsgpio.h irshfftp.cpp irshfftp.h irsinit.cpp irsinit.h irsint.cpp irsint.h irskbd.cpp irskbd.h irslimits.h irslocale.cpp irslocale.h irslwip.cpp irslwip.h irsmath.cpp irsmath.h irsmatrix.cpp irsmatrix.h irsmbus.cpp irsmbus.h irsmcutil.cpp irsmcutil.h irsmem.cpp irsmem.h irsmenu.cpp irsmenu.h irsnetdefs.h irsparamabs.h irspch.h irsprop.cpp irsprop.h irsrect.h irsspi.h irsstd.cpp irsstd.h irsstrconv.h irsstrdefs.h irsstring.cpp irsstring.h irsstrm.cpp irsstrm.h irsstrmstd.h irssysutils.cpp irssysutils.h irstable.h irstcpip.cpp irstcpip.h irstest.h irstime.cpp irstime.h irstree.h irsvariant.cpp irsvariant.h lwipopts.h measdef.h measmul.cpp measmul.h meassup.cpp meassup.h mxdata.cpp mxdata.h mxdatastd.h mxextbase.cpp mxextbase.h mxextchart.cpp mxextchart.h mxifa.h mxifar.cpp mxifar.h mxnet.cpp mxnet.h mxnetc.cpp mxnetc.h mxnetd.h mxnetr.cpp mxnetr.h niusbgpib.cpp niusbgpib.h niusbgpib_hardflow.cpp niusbgpib_hardflow.h timer.cpp timer.h tstlan4abs.h
  group main
    ./: app.cpp app.h cfg.cpp cfg.h comm.cpp comm.h data.h demux.h main.cpp privatecfg.h supply.cpp supply.h
    ../u309m_common/: common_data.h
