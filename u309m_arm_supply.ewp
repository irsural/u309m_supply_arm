# IAR project u309m_arm_supply.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __LM3SxBxx__
  ICCARM.CCDiagSuppress: Pa039, Pe261, Pe340, Pa091, Pa089
  ICCARM.CCIncludePath2: ..\mxsrclib\arch\arm\; ..\mxsrclib\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: u309m_arm_supply.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: u309m_arm_supply.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 5.srec
  group (top)
    ./: app.cpp app.h cfg.cpp cfg.h comm.cpp comm.h data.h demux.h main.cpp privatecfg.h supply.cpp supply.h
  group lib
    ../mxsrclib/: irsadc.cpp irsadc.h irscpu.cpp irscpu.h irsdev.cpp irsdev.h irsdsp.cpp irsdsp.h irsgpio.h irsint.cpp irsint.h irsmem.cpp irsmem.h irsspi.h timer.cpp timer.h
  group lib/arch
    ../mxsrclib/arch/arm/: armadc.cpp armadc.h armcfg.cpp armcfg.h armeth.cpp armeth.h armflash.cpp armflash.h armgpio.cpp armgpio.h armiomacros.h armioregs.h armspi.cpp armspi.h counter.cpp counter.h irsarchint.cpp irsarchint.h irsarmutil.cpp irsarmutil.h
  group lib/Ненужное
    ../mxsrclib/: hardflowg.cpp hardflowg.h irsalg.cpp irsalg.h irsconfig.h irscpp.h irsdefs.h irserror.cpp irserror.h irsexcept.cpp irsexcept.h irsfinal.h irslimits.h irsmbus.cpp irsmbus.h irsnetdefs.h irsstd.cpp irsstd.h irsstring.h irsstrm.h irsstrmstd.h irssysutils.h irstable.h irstcpip.cpp irstcpip.h irstest.h irstime.cpp irstime.h measdef.h meassup.cpp meassup.h mxdata.cpp mxdata.h mxdatastd.h
